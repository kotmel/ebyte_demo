# IAR project project.ewp, settings and files
configuration E15-EVB02_E19-433M20SC (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G4 STM8L151G4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: EBYTE_E19_433M20SC
  ICCSTM8.CCIncludePath2: ..\..\..\2_Ebyte_Board_Support\E15-EVB02; ..\..\..\3_Ebyte_WirelessModule_Drivers\E19xMx; ..\..\..\4_STM8_L15x_StdPeriph_Drivers\inc; ..\..\..\4_STM8_L15x_StdPeriph_Drivers; ..\..\..\1_Middleware\Kfifo; ..\..\..\3_Ebyte_WirelessModule_Drivers; ..\..\..\1_Middleware\Produce
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration E15-EVB02_E10-400M20S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E10_400M20S
  ICCSTM8.CCIncludePath2: ..\..\..\2_Ebyte_Board_Support\E15-EVB02; ..\..\..\3_Ebyte_WirelessModule_Drivers\E10xMx; ..\..\..\4_STM8_L15x_StdPeriph_Drivers\inc; ..\..\..\4_STM8_L15x_StdPeriph_Drivers; ..\..\..\1_Middleware\Kfifo; ..\..\..\3_Ebyte_WirelessModule_Drivers; ..\..\..\1_Middleware\Produce
configuration E15-EVB02_E49-400M20S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E49_400M20S
  ICCSTM8.CCIncludePath2: ..\..\..\2_Ebyte_Board_Support\E15-EVB02; ..\..\..\3_Ebyte_WirelessModule_Drivers\E49xMx; ..\..\..\4_STM8_L15x_StdPeriph_Drivers\inc; ..\..\..\4_STM8_L15x_StdPeriph_Drivers; ..\..\..\1_Middleware\Kfifo; ..\..\..\3_Ebyte_WirelessModule_Drivers; ..\..\..\1_Middleware\Produce
configuration E15-EVB02_E49-900M20S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E49_900M20S
  ICCSTM8.CCIncludePath2: as above
configuration E15-EVB02_E07-400M10S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E07_400M10S
  ICCSTM8.CCIncludePath2: ..\..\..\2_Ebyte_Board_Support\E15-EVB02; ..\..\..\3_Ebyte_WirelessModule_Drivers\E07xMx; ..\..\..\4_STM8_L15x_StdPeriph_Drivers\inc; ..\..\..\4_STM8_L15x_StdPeriph_Drivers; ..\..\..\1_Middleware\Kfifo; ..\..\..\3_Ebyte_WirelessModule_Drivers; ..\..\..\1_Middleware\Produce
configuration E15-EVB02_E22-400M22S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E22_400M22S
  ICCSTM8.CCIncludePath2: ..\..\..\2_Ebyte_Board_Support\E15-EVB02; ..\..\..\3_Ebyte_WirelessModule_Drivers\E22xMx; ..\..\..\4_STM8_L15x_StdPeriph_Drivers\inc; ..\..\..\4_STM8_L15x_StdPeriph_Drivers; ..\..\..\1_Middleware\Kfifo; ..\..\..\3_Ebyte_WirelessModule_Drivers; ..\..\..\1_Middleware\Produce
configuration E15-EVB02_E22-900M22S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E22_900M22S
  ICCSTM8.CCIncludePath2: as above
configuration E15-EVB02_E220-400M22S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E220_400M22S
  ICCSTM8.CCIncludePath2: ..\..\..\2_Ebyte_Board_Support\E15-EVB02; ..\..\..\3_Ebyte_WirelessModule_Drivers\E220xMx; ..\..\..\4_STM8_L15x_StdPeriph_Drivers\inc; ..\..\..\4_STM8_L15x_StdPeriph_Drivers; ..\..\..\1_Middleware\Kfifo; ..\..\..\3_Ebyte_WirelessModule_Drivers; ..\..\..\1_Middleware\Produce
configuration E15-EVB02_E220-900M22S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E220_900M22S
  ICCSTM8.CCIncludePath2: as above
configuration E15-EVB02_E07-900M10S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E07_900M10S
  ICCSTM8.CCIncludePath2: as above
configuration E15-EVB02_E30-900M20S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E30_900M20S
  ICCSTM8.CCIncludePath2: ..\..\..\2_Ebyte_Board_Support\E15-EVB02; ..\..\..\3_Ebyte_WirelessModule_Drivers\E30xMx; ..\..\..\4_STM8_L15x_StdPeriph_Drivers\inc; ..\..\..\4_STM8_L15x_StdPeriph_Drivers; ..\..\..\1_Middleware\Kfifo; ..\..\..\3_Ebyte_WirelessModule_Drivers; ..\..\..\1_Middleware\Produce
configuration E15-EVB02_E31-400M17S (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: EBYTE_E31_400M17S
  ICCSTM8.CCIncludePath2: ..\..\..\2_Ebyte_Board_Support\E15-EVB02; ..\..\..\3_Ebyte_WirelessModule_Drivers\E31xMx; ..\..\..\4_STM8_L15x_StdPeriph_Drivers\inc; ..\..\..\4_STM8_L15x_StdPeriph_Drivers; ..\..\..\1_Middleware\Kfifo; ..\..\..\3_Ebyte_WirelessModule_Drivers; ..\..\..\1_Middleware\Produce
  group Board
    ../../../2_Ebyte_Board_Support/E15-EVB02/: board.c board_button.c board_mini_printf.c
  group Drivers/Ebyte/RF
    ../../../3_Ebyte_WirelessModule_Drivers/: ebyte_core.c
  group Drivers/Ebyte/RF/E07x
    ../../../3_Ebyte_WirelessModule_Drivers/E07xMx/: ebyte_callback.c ebyte_e07x.c ebyte_port.c
  group Drivers/Ebyte/RF/E10x
    ../../../3_Ebyte_WirelessModule_Drivers/E10xMx/: ebyte_callback.c ebyte_e10x.c ebyte_port.c
  group Drivers/Ebyte/RF/E19x
    ../../../3_Ebyte_WirelessModule_Drivers/E19xMx/: ebyte_callback.c ebyte_e19x.c ebyte_port.c
  group Drivers/Ebyte/RF/E220x
    ../../../3_Ebyte_WirelessModule_Drivers/E220xMx/: ebyte_callback.c ebyte_e220x.c ebyte_port.c
  group Drivers/Ebyte/RF/E22x
    ../../../3_Ebyte_WirelessModule_Drivers/E22xMx/: ebyte_callback.c ebyte_e22x.c ebyte_port.c
  group Drivers/Ebyte/RF/E30x
    ../../../3_Ebyte_WirelessModule_Drivers/E30xMx/: ebyte_callback.c ebyte_e30x.c ebyte_port.c
  group Drivers/Ebyte/RF/E31x
    ../../../3_Ebyte_WirelessModule_Drivers/E31xMx/: ebyte_callback.c ebyte_e31x.c ebyte_port.c
  group Drivers/Ebyte/RF/E49x
    ../../../3_Ebyte_WirelessModule_Drivers/E49xMx/: ebyte_callback.c ebyte_e49x.c ebyte_port.c
  group Drivers/MCU
    ../../../4_STM8_L15x_StdPeriph_Drivers/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group Main
    ./: main.c stm8l15x_it.c
  group Middleware
    ../../../1_Middleware/Produce/: ebyte_debug.c
    ../../../1_Middleware/Kfifo/: ebyte_kfifo.c
